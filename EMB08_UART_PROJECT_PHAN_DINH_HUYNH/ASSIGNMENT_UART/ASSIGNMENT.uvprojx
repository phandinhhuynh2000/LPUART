# Keil uVision project ASSIGNMENT.uvprojx, settings and files
target assignment_uart (6210000::V6.21::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ASSIGNMENT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group source
    ./source/: main.c clock.c nvic.c delay.c lpuart.c PORT_IRQHANDLER.c
  group include
    ./include/: pcc.h gpio.h common.h clock.h nvic.h port.h main.h lpit.h lpuart.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
